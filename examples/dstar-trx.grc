options:
  parameters:
    author: Hansi Reiser dl9rdz
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: D-Star DD Transceiver
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: int(1242.45e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: squelch
  id: variable
  parameters:
    value: '-70'
  states: {}
- name: tx_power
  id: variable_qtgui_range
  parameters:
    label: TX Power
    rangeType: int
    start: '0'
    step: '1'
    stop: '80'
    value: '70'
  states: {}
- name: variable_qtgui_check_box_0
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: verbosex
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.5'
    gate: 'True'
    ramp: '2'
    threshold: squelch
    type: complex
  states: {state: bypassed}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/jann/DStar/new.cplx
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dl9rdz/hackrf/kurz.cplx
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/dl9rdz/hackrf/test.cplx
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/2
    type: complex
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: 0.0102*0
    gain_mu: 0.175+0.3
    mu: '0.5'
    omega_relative_limit: 0.050/5
    samples_per_symbol: '4'
  states: {}
- name: digital_gmsk_demod_0_0
  id: digital_gmsk_demod
  parameters:
    freq_error: 0.0102*0
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: 0.050/5
    samples_per_symbol: '4'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '8'
  states: {}
- name: dstardd_dstardd_decoder_0
  id: dstardd_dstardd_decoder
  parameters:
    verbose: verbosex
  states: {}
- name: dstardd_dstardd_decoder_0_0
  id: dstardd_dstardd_decoder
  parameters:
    verbose: verbosex
  states: {state: disabled}
- name: dstardd_dstardd_encoder_0
  id: dstardd_dstardd_encoder
  parameters:
    dst_call: CQCQCQ
    packed_output: 'True'
    rptr1_call: CQCQCQ
    rptr2_call: CQCQCQ
    src_call: CQCQCQ
    type: '0xC0'
    verbose: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 60e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 200e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 60e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: network_tuntap_pdu_0
  id: network_tuntap_pdu
  parameters:
    ifn: dstar0
    istunflag: 'False'
    mtu: '10000'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: B210
    dev_args: '""'
    gain0: tx_power
    len_tag_name: ''
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    dev_addr: B210
    dev_args: '""'
    gain0: '40'
    otw: sc16
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [analog_pwr_squelch_xx_0, '0', digital_gmsk_demod_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_1, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_throttle_0, '0', analog_pwr_squelch_xx_0, '0']
- [digital_gmsk_demod_0, '0', dstardd_dstardd_decoder_0, '0']
- [digital_gmsk_demod_0_0, '0', dstardd_dstardd_decoder_0_0, '0']
- [digital_gmsk_mod_0, '0', virtual_sink_0, '0']
- [dstardd_dstardd_decoder_0, pdu, network_tuntap_pdu_0, pdus]
- [dstardd_dstardd_encoder_0, '0', digital_gmsk_mod_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_file_sink_1, '0']
- [low_pass_filter_0_0, '0', digital_gmsk_demod_0_0, '0']
- [network_tuntap_pdu_0, pdus, dstardd_dstardd_encoder_0, pdu]
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.8.0
